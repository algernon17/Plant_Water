//!****************************************
//! plant_water_1
//!   with lcd_2x16
//!   switch x6
//!   motor
//! Peter Swinburne
//! 08/21/2016
//!****************************************
#include <LiquidCrystal.h>

//! DEBUG
#define DEBUG_MODE  1           //! comment out for Production
#define SECONDSMULTIPLIER  256L //! this should be 1

//! INPUTS & OUTPUTS
#define CRIGHT     10
#define MOTOR      11
#define GO_INPUT   12
#define BRD_LED    13

#define LED_OFF    0
#define LED_ON     1
#define MOTOR_OFF  0
#define MOTOR_ON   1

#define SECONDSPERDAY      (24L * 60L * 60L) / SECONDSMULTIPLIER

enum STATE_VALUES
{
  STOP_STATE = 0,
  RUN_STATE  = 10
};

//! VARIABLES
LiquidCrystal lcd(4, 5, 6, 7, 8, 9);

int t = 0;
int cursor_flash = -1;
int state = RUN_STATE; //@@@STOP_STATE;
int schedule[7] = {1, 2, 3, 4, 3, 2, 1};
int motor_flag = MOTOR_OFF;
int motor_period = 0;
long second_count = 0L;

//!****************************************
//! SWITCH DEBOUNCE
//!****************************************
void switch_debounce()
{
  digitalWrite(BRD_LED, LED_OFF);
  while(digitalRead(GO_INPUT) == 1);  //! wait for a zero
  digitalWrite(BRD_LED, LED_ON);
  delay(200);
  while(digitalRead(GO_INPUT) == 0);  //! wait for a zero
}

//!****************************************
//! SETUP
//!****************************************
void setup()
{
  pinMode(CRIGHT,   INPUT);
  pinMode(GO_INPUT, INPUT);
  pinMode(BRD_LED,  OUTPUT);
  pinMode(MOTOR,    OUTPUT);

  lcd.begin(16,2);

  //@@@attachInterrupt( 0, run_stop_switch, FALLING );

  //! go switch and onboard LED
  switch_debounce();
  setup_lcd();
  #ifdef DEBUG_MODE
  Serial.begin( 9600 );
  #endif
}

//!****************************************
//! Setup LCD
//!****************************************
void setup_lcd()
{
  lcd.clear();
  lcd.setCursor(0,0);
  lcd.print("DHHMM  T MTWTFSS");
  lcd.setCursor(0,1);
  lcd.print("00000  0 0000000");
}

//!****************************************
//! LOOP
//!****************************************
void loop()
{
  delay(1000);
  second_count++;

  #ifdef DEBUG_MODE
  Serial.print("SizeOf int = ");
  Serial.print(sizeof(int));
  Serial.print("\n");
  #endif

  if(STOP_STATE == state)
  {
    //! wait for input
    while(digitalRead(CRIGHT) == 1);
    //@@@lcd.setCursor(0,0);
    //@@@lcd.blink();
    cursor_flash++;
    digitalWrite(BRD_LED, LED_ON);
    analogWrite(MOTOR, 96);
    delay(2000);
    analogWrite(MOTOR, 0);
    delay(5000);
    //@@@lcd.noBlink();
    digitalWrite(BRD_LED, LED_OFF);
  }
  else if(RUN_STATE == state)
  {
    digitalWrite(BRD_LED, LED_OFF);
    if(second_count == SECONDSPERDAY)
    {
      second_count = 0;
      motor_flag = MOTOR_ON;
      motor_period = 5; //@@@ test period
	}
  }

  if(MOTOR_ON == motor_flag)
  {
    if(motor_period == 0)
    {
      motor_flag = MOTOR_OFF;
      analogWrite(MOTOR, 96);
    }
    else
    {
      analogWrite(MOTOR, 96);
      motor_period--;
	}
  }

}


//!****************************************
//! END OF MODULE
//!****************************************


